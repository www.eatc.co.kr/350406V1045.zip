# Autodesk Inventor part: 8.가변스프링
## iProperties
Created: 2015-04
Part Number: 8.가변스프링
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
